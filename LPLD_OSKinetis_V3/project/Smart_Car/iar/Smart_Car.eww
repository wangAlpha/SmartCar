<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Smart_Car_K60D10.ewp</path>
  </project>
  <batchBuild></batchBuild>
</workspace>